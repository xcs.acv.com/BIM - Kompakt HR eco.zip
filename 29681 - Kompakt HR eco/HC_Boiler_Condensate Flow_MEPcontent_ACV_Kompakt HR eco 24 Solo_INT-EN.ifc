Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-05-25T15:26:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 25 15:26:54 2021 * Host: RVIDREA-RO-LE * Database: C:\Users\RVidrea\AppData\Local\Temp\{DBD2D74D-E3E4-4A00-A2BB-75C0531D861A}\ifc * Database version: 5507 * Database creation date: Tue May 25 15:26:53 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 25 15:26:53 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 25 15:26:53 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: Kompakt HR eco 24 Solo, HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HR eco_24 Solo_INT-EN:Kompakt HR eco 24 Solo:1402027
In: V00
Type - PredefinedType: WATER; Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 073-073-073, Color RGB 155-155-155
Type - Dimensions - Air Supply Diameter: 80 mm; Depth: 270 mm; Drain Diameter: 25 mm; Flue Gas Diameter: 80 mm; Gas Diameter: 12.7 mm; Height: 750 mm; Hydronic Diameter: 19.05 mm; Use Nominal Diameter: yes; Width: 450 mm
Type - Electrical - Input: 23700 W; Max Power Boiler: 22700 W; Min Power Boiler: 6900 W; Voltage: 230 V
Type - Electrical - Loads - Power: 35 W
Type - Identity Data - Article Type: Kompakt HR eco 24 Solo; Base Family Version: 12.27; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: High efficiency wall mounted gas condensing boiler; EMCS Version: 4.0; ETIM Article Class: EC010232; Family Version: 12.27; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/3472; MEPcontent Class: BOILER; Model: Kompakt HR eco 24 Solo; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2018; Type Name: Kompakt HR eco 24 Solo; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Grey: Color RGB 073-073-073; Grey: Color RGB 155-155-155; White: Color RGB 222-222-222
Type - Mechanical - Gas Flow Rate Max: 0.000541667 m3/s; Maximum Supply Temperature (Operating Temperature): 90 kg/K/s3; Max Pressure Heating: 300000 Pa; Weight: 30
Type - Other - Category: Mechanical Equipment; Chimney Agreement: B23-B33-C13-C33-C43-C53-C83-C93; Class: 44; Family Name: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HR eco_24 Solo_INT-EN; Space Heating Energy Efficiency Class: A
Type - Text - Article Description: High efficiency wall mounted gas condensing boiler; GTIN: 5400891002933; Manufacturer Art. No.: 08658301; Pipe Type Category: M561; Product Line: Kompakt HR eco
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Area: 0.848229 m2; Volume: 0.0866714 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Air Supply Flow: 0 m3/s; Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Supply,Hydronic Return,Sanitary,Power,Other,Supply Air,Other Air
Other - Family: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HR eco_24 Solo_INT-EN: Kompakt HR eco 24 Solo; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HR eco_24 Solo_INT-EN: Kompakt HR eco 24 Solo; Reference Line Width: 330 mm; Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HR eco_24 Solo_INT-EN: Kompakt HR eco 24 Solo; Type Id: HC_Boiler_Condensate Flow_MEPcontent_ACV_Kompakt HR eco_24 Solo_INT-EN: Kompakt HR eco 24 Solo
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Left Supply Connection: yes; Right Supply Connection: no
